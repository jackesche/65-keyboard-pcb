# Repository jackesche/65-keyboard-pcb

File README.md:

# 65-keyboard-pcb
A 65% ANSI-only keyboard pcb

## KiCad design 65-keyboard-pcb.kicad_pcb

Parts:
C1: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C3: 22p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4, C5, C6, C7: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C8: 4.7u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D45, D46, D47, D50, D54, D55, D56, D57: 22p; D_SOD-123
F1: 500mA; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: USB4085-GF-A_REVA; GCT_USB4085-GF-A_REVA
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX14, MX17, MX18, MX19, MX20, MX21, MX22, MX23, MX24, MX25, MX26, MX28, MX32, MX33, MX34, MX35, MX36, MX37, MX38, MX39, MX40, MX42, MX43, MX46, MX55, MX56, MX57: MX-NoLED; MXOnly-1U-NoLED
MX16, MX41, MX45, MX47, MX54: MX-NoLED; MXOnly-1.25U-NoLED
MX27, MX31: MX-NoLED; MXOnly-1.75U-NoLED
MX50: MX-NoLED; MXOnly-6.25U-ReversedStabilizers-NoLED
R1, R6: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2, R3: 22 ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4, R5: 5.1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1: SW_PUSH; SW_SPST_TL3342
U1: ATMEGA32U4; TQFP-44_10x10mm_P0.8mm
X1: XTAL_GND; Crystal_SMD_SeikoEpson_FA238-4Pin_3.2x2.5mm_HandSoldering

Connections:
+5V: C4.1, C5.1, C6.1, C7.1, C8.1, F1.2, R6.1, U1.2, U1.7, U1.14, U1.24, U1.34, U1.44
COL0: MX1.1 (COL), MX16.1 (COL), MX31.1 (COL), MX45.1 (COL), U1.40
COL1: MX2.1 (COL), MX17.1 (COL), MX32.1 (COL), MX46.1 (COL), U1.39
COL2: MX3.1 (COL), MX18.1 (COL), MX33.1 (COL), MX47.1 (COL), U1.38
COL3: MX4.1 (COL), MX19.1 (COL), MX34.1 (COL), U1.37
COL4: MX5.1 (COL), MX20.1 (COL), MX35.1 (COL), U1.36
COL5: MX6.1 (COL), MX21.1 (COL), MX36.1 (COL), MX50.1 (COL), U1.32
COL6: MX7.1 (COL), MX22.1 (COL), MX37.1 (COL), U1.31
COL7: MX8.1 (COL), MX23.1 (COL), MX38.1 (COL), U1.41
COL8: MX9.1 (COL), MX24.1 (COL), MX39.1 (COL), U1.25
COL9: MX10.1 (COL), MX25.1 (COL), MX40.1 (COL), MX54.1 (COL), U1.22
COL10: MX11.1 (COL), MX26.1 (COL), MX41.1 (COL), MX55.1 (COL), U1.21
COL11: MX12.1 (COL), MX27.1 (COL), MX42.1 (COL), MX56.1 (COL), U1.20
COL12: MX13.1 (COL), MX28.1 (COL), MX43.1 (COL), MX57.1 (COL), U1.19
COL13: MX14.1 (COL), U1.12
D+: R3.1, U1.4
D-: R2.1, U1.3
unnamed: C1.1, U1.6
unnamed: D1.2 (A), MX1.2 (ROW)
unnamed: D2.2 (A), MX2.2 (ROW)
unnamed: D3.2 (A), MX3.2 (ROW)
unnamed: D4.2 (A), MX4.2 (ROW)
unnamed: D5.2 (A), MX5.2 (ROW)
unnamed: D6.2 (A), MX6.2 (ROW)
unnamed: D7.2 (A), MX7.2 (ROW)
unnamed: D8.2 (A), MX8.2 (ROW)
unnamed: D9.2 (A), MX9.2 (ROW)
unnamed: D10.2 (A), MX10.2 (ROW)
unnamed: D11.2 (A), MX11.2 (ROW)
unnamed: D12.2 (A), MX12.2 (ROW)
unnamed: D13.2 (A), MX13.2 (ROW)
unnamed: D14.2 (A), MX14.2 (ROW)
unnamed: D16.2 (A), MX16.2 (ROW)
unnamed: D17.2 (A), MX17.2 (ROW)
unnamed: D18.2 (A), MX18.2 (ROW)
unnamed: D19.2 (A), MX19.2 (ROW)
unnamed: D20.2 (A), MX20.2 (ROW)
unnamed: D21.2 (A), MX21.2 (ROW)
unnamed: D22.2 (A), MX22.2 (ROW)
unnamed: D23.2 (A), MX23.2 (ROW)
unnamed: D24.2 (A), MX24.2 (ROW)
unnamed: D25.2 (A), MX25.2 (ROW)
unnamed: D26.2 (A), MX26.2 (ROW)
unnamed: D27.2 (A), MX27.2 (ROW)
unnamed: D28.2 (A), MX28.2 (ROW)
unnamed: D31.2 (A), MX31.2 (ROW)
unnamed: D32.2 (A), MX32.2 (ROW)
unnamed: D33.2 (A), MX33.2 (ROW)
unnamed: D34.2 (A), MX34.2 (ROW)
unnamed: D35.2 (A), MX35.2 (ROW)
unnamed: D36.2 (A), MX36.2 (ROW)
unnamed: D37.2 (A), MX37.2 (ROW)
unnamed: D38.2 (A), MX38.2 (ROW)
unnamed: D39.2 (A), MX39.2 (ROW)
unnamed: D40.2 (A), MX40.2 (ROW)
unnamed: D41.2 (A), MX41.2 (ROW)
unnamed: D42.2 (A), MX42.2 (ROW)
unnamed: D43.2 (A), MX43.2 (ROW)
unnamed: D45.2 (A), MX45.2 (ROW)
unnamed: D46.2 (A), MX46.2 (ROW)
unnamed: D47.2 (A), MX47.2 (ROW)
unnamed: D50.2 (A), MX50.2 (ROW)
unnamed: D54.2 (A), MX54.2 (ROW)
unnamed: D55.2 (A), MX55.2 (ROW)
unnamed: D56.2 (A), MX56.2 (ROW)
unnamed: D57.2 (A), MX57.2 (ROW)
unnamed: J1.A5 (CC1), R5.2
unnamed: J1.A6 (DP1), J1.B6 (DP2), R3.2
unnamed: J1.A7 (DN1), J1.B7 (DN2), R2.2
unnamed: J1.B5 (CC2), R4.2
unnamed: R1.1, U1.33
RESET: R6.2, SW1.2, U1.13
ROW0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), U1.26
ROW1: D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), U1.27
ROW2: D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), U1.28
ROW3: D45.1 (K), D46.1 (K), D47.1 (K), D50.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), U1.29
VCC: F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
XTAL1: C2.1, U1.16, X1.1

Notes on the sheet:
Crystal
Reset
USB-C 2.0
Decoupling Caps
@MEGA

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
Board: 2 copper layers, 276.2 x 85.7 mm, 115 parts (66 on the bottom side), 80 nets.

## Commit log

2020-09-01 Design matrix
2020-09-01 Complete schematic
2020-09-02 Place components
2020-09-02 Component placement
2020-09-03 Add reference
2020-09-08 Route traces
